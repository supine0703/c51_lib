# Keil uVision project demo_4.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: demo_4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group main
    ./: STARTUP.A51 main.c __config__.h
  group delay
    ../../lib/delay/: delay_c52.c delay_c52.h
  group lcd1602
    ../../lib/lcd1602/: lcd1602.c lcd1602.h
