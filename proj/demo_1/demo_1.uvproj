# Keil uVision project demo_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: demo_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib
  group main
    ./: STARTUP.A51 __config__.h main.c
  group buzzer
    ../../lib/buzzer/: buzzer.h
  group delay
    ../../lib/delay/: delay_c52.c delay_c52.h
  group ds18b20
    ../../lib/ds18b20/: ds18b20.c ds18b20.h
  group hc_sr04
    ../../lib/hc_sr04/: hc_sr04.c hc_sr04.h
  group key_4x4
    ../../lib/key_4x4/: key_4x4.c key_4x4.h
  group lcd1602
    ../../lib/lcd1602/: lcd1602.c lcd1602.h
  group motor
    ../../lib/motor/: dc_motor.h step_motor.c step_motor.h
