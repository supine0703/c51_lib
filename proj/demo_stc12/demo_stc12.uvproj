# Keil uVision project demo_stc12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: demo_stc12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib_beta\stc12\c_lib
  group main
    ./: STARTUP.A51 main.c
  group header
    ./: u_type.h __config__.h function.h
  group source
    ../../lib_beta/stc12/c_lib/: delay.c key_4x4.c lcd12864.c hx711.c
