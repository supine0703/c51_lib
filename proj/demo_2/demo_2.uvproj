# Keil uVision project demo_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group main
    ./: STARTUP.A51 __config__.h main.c
  group lib
    ./lib/: step_motor.c step_motor.h
