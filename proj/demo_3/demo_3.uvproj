# Keil uVision project demo_3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo_3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c __config__.h delay.c delay.h lcd1602.c lcd1602.h ds18b20.c ds18b20.h hc_sr04.c hc_sr04.h key_4x4.c key_4x4.h
