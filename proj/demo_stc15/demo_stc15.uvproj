# Keil uVision project demo_stc15.uvproj, settings and files
target STC15 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: demo_stc15 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lib_beta\stc15\c_lib;..\..\lib_beta\stc15\other;..\..\lib_beta\stc15\FATFS
  group main
    ./: STARTUP.A51 main.c variable.c system.c system.h
  group header
    ./: __type__.h __config__.h __function__.h
  group include
    ../../lib_beta/stc15/c_lib/: i2c.h spi.h
  group source
    ../../lib_beta/stc15/c_lib/: delay.c key_4x4.c i2c.c spi.c at24c.c lcd12864.c dht11.c ds18b20.c ds1302.c hc_sr04.c adc.c pwm.c step_motor.c
  group other
    ../../lib_beta/stc15/other/: mp3player.c mp3player.h sd.c sd.h vs1053.c vs1053.h
  group FATFS
    ../../lib_beta/stc15/FATFS/: 00readme.txt diskio.c diskio.h integer.h pff.c pff.h pffconf.h
